# IAR project Backup of FSBL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 0
  ICCARM.CCDefines: __FSBL__
  ICCARM.CCIncludePath2: ..\FM_ZQ_hw_platform; ..\FM_ZQ_bsp\include; ..\FM_ZQ_bsp\bootloader; ..\FM_ZQ_bsp\bootloader\armv8; ..\FM_ZQ_bsp\libsrc; ..\FM_ZQ_bsp\libsrc\axidmapsu_v1_0; ..\FM_ZQ_bsp\libsrc\bbramps_v1_0; ..\FM_ZQ_bsp\libsrc\canfdps_v1_0; ..\FM_ZQ_bsp\libsrc\ccips_v1_1; ..\FM_ZQ_bsp\libsrc\common_v1_0; ..\FM_ZQ_bsp\libsrc\common_v1_0\armv8; ..\FM_ZQ_bsp\libsrc\devcps_v1_0; ..\FM_ZQ_bsp\libsrc\efuseps_v1_0; ..\FM_ZQ_bsp\libsrc\gicps_v1_0; ..\FM_ZQ_bsp\libsrc\gpiops_v1_1; ..\FM_ZQ_bsp\libsrc\gtc_v1_0; ..\FM_ZQ_bsp\libsrc\gtrpsu_v1_0; ..\FM_ZQ_bsp\libsrc\i2cps_v1_0; ..\FM_ZQ_bsp\libsrc\ipi_v1_1; ..\FM_ZQ_bsp\libsrc\nandpsu_v1_0; ..\FM_ZQ_bsp\libsrc\qspipsu_v1_0; ..\FM_ZQ_bsp\libsrc\rtcps_v1_0; ..\FM_ZQ_bsp\libsrc\sdpsu_v1_0; ..\FM_ZQ_bsp\libsrc\slcrps_v1_0; ..\FM_ZQ_bsp\libsrc\spips_v2_0; ..\FM_ZQ_bsp\libsrc\ttcps_v1_1; ..\FM_ZQ_bsp\libsrc\uartps_v1_0; ..\FM_ZQ_bsp\libsrc\usbps_v1_0; ..\FM_ZQ_bsp\libsrc\wdtps_v1_0; ..\FM_ZQ_bsp\libsrc\pm_v1_0; ..\FM_ZQ_bsp\libsrc\pm_v1_0\apu; ..\FM_ZQ_bsp\thirdpartlib; ..\FM_ZQ_bsp\thirdpartlib\Fatfs15; ..\FM_ZQ_fsbl
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __FSBL__
  AARM.AUserIncludes: ..\FM_ZQ_hw_platform; ..\FM_ZQ_bsp\include; ..\FM_ZQ_bsp\bootloader; ..\FM_ZQ_bsp\libsrc; ..\FM_ZQ_bsp\libsrc\common_v1_0; ..\FM_ZQ_bsp\bootloader\armv8
  OBJCOPY.OOCOutputFile: Fsbl_CA53.bin
  postbuild: cmd.exe /c copy "$TARGET_PATH$" "..\Images\"
  ILINK.IlinkOutputFile: Fsbl_CA53.out
  ILINK.IlinkIcfFile: ca53_axisram.icf
  ILINK.IlinkProgramEntryLabel: Start64
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group FM_ZQ_bsp/bootloader/armv8
    ../FM_ZQ_bsp/bootloader/armv8/: bspconfig.h exception_handler.c exception_handler.h startup.S translation_table.S translation_table_el1.S vectors.S
  group FM_ZQ_bsp/include
    ../FM_ZQ_bsp/include/: fmsh_psu_parameters.h
  group FM_ZQ_bsp/libsrc/axidmapsu_v1_0
    ../FM_ZQ_bsp/libsrc/axidmapsu_v1_0/: fmsh_axidmapsu.c fmsh_axidmapsu.h fmsh_axidmapsu_g.c fmsh_axidmapsu_hw.h fmsh_axidmapsu_lib.h
  group FM_ZQ_bsp/libsrc/bbramps_v1_0
    ../FM_ZQ_bsp/libsrc/bbramps_v1_0/: fmsh_bbram.c fmsh_bbram_common.h fmsh_bbram_g.c fmsh_bbram_lib.h fmsh_bbram_private.h fmsh_bbram_public.h fmsh_bbram_sinit.c
  group FM_ZQ_bsp/libsrc/canfdps_v1_0
    ../FM_ZQ_bsp/libsrc/canfdps_v1_0/: fmsh_can.c fmsh_can_common.h fmsh_can_g.c fmsh_can_lib.h fmsh_can_private.h fmsh_can_public.h fmsh_can_sinit.c
  group FM_ZQ_bsp/libsrc/ccips_v1_1
    ../FM_ZQ_bsp/libsrc/ccips_v1_1/: fmsh_cci.c fmsh_cci.h fmsh_cci_hw.h
  group FM_ZQ_bsp/libsrc/common_v1_0
    ../FM_ZQ_bsp/libsrc/common_v1_0/: fmsh_common.c fmsh_common.h fmsh_common_bitops.h fmsh_common_dbc.h fmsh_common_delay.h fmsh_common_dev.h fmsh_common_io.h fmsh_common_list.h fmsh_common_status.h fmsh_common_types.h fmsh_gtc_delay.c fmsh_pseudo_asm.h iar_retarget.c
  group FM_ZQ_bsp/libsrc/common_v1_0/armv8
    ../FM_ZQ_bsp/libsrc/common_v1_0/armv8/: cortexa53.h fmsh_cache.c fmsh_cache.h fmsh_mmu.c fmsh_mmu.h PPM_AEM.h v8_aarch64.S v8_mmu.h v8_system.h v8_utils.S
  group FM_ZQ_bsp/libsrc/devcps_v1_0
    ../FM_ZQ_bsp/libsrc/devcps_v1_0/: fmsh_devc.c fmsh_devc_common.h fmsh_devc_g.c fmsh_devc_lib.h fmsh_devc_private.h fmsh_devc_public.h fmsh_devc_sinit.c
  group FM_ZQ_bsp/libsrc/efuseps_v1_0
    ../FM_ZQ_bsp/libsrc/efuseps_v1_0/: fmsh_efuse.c fmsh_efuse.h
  group FM_ZQ_bsp/libsrc/gicps_v1_0
    ../FM_ZQ_bsp/libsrc/gicps_v1_0/: fmsh_gic.c fmsh_gic.h fmsh_gic_hw.h fmsh_gic_intr.c fmsh_gic_sinit.c
  group FM_ZQ_bsp/libsrc/gpiops_v1_1
    ../FM_ZQ_bsp/libsrc/gpiops_v1_1/: fmsh_gpio.c fmsh_gpio_common.h fmsh_gpio_g.c fmsh_gpio_lib.h fmsh_gpio_private.h fmsh_gpio_public.h fmsh_gpio_sinit.c
  group FM_ZQ_bsp/libsrc/gtcps_v1_0
    ../FM_ZQ_bsp/libsrc/gtc_v1_0/: fmsh_gtc.c fmsh_gtc_common.h fmsh_gtc_g.c fmsh_gtc_lib.h fmsh_gtc_private.h fmsh_gtc_public.h fmsh_gtc_sinit.c
  group FM_ZQ_bsp/libsrc/gtrpsu_v1_0
    ../FM_ZQ_bsp/libsrc/gtrpsu_v1_0/: fmsh_gtr.c fmsh_gtr.h
  group FM_ZQ_bsp/libsrc/i2cps_v1_0
    ../FM_ZQ_bsp/libsrc/i2cps_v1_0/: fmsh_i2c.c fmsh_i2c_common.h fmsh_i2c_g.c fmsh_i2c_lib.h fmsh_i2c_private.h fmsh_i2c_public.h fmsh_i2c_sinit.c
  group FM_ZQ_bsp/libsrc/ipi_v1_1
    ../FM_ZQ_bsp/libsrc/ipi_v1_1/: fmsh_ipi.c fmsh_ipi.h fmsh_ipi_buf.c fmsh_ipi_buf.h fmsh_ipi_g.c fmsh_ipi_hw.h fmsh_ipi_sinit.c
  group FM_ZQ_bsp/libsrc/nandpsu_v1_0
    ../FM_ZQ_bsp/libsrc/nandpsu_v1_0/: fmsh_hpnfc.c fmsh_hpnfc.h fmsh_hpnfc_bbm.c fmsh_hpnfc_bbm.h fmsh_hpnfc_flash.c fmsh_hpnfc_flash.h fmsh_hpnfc_g.c fmsh_hpnfc_hw.c fmsh_hpnfc_hw.h fmsh_hpnfc_sinit.c fmsh_hpnfc_skip.c fmsh_hpnfc_skip.h
  group FM_ZQ_bsp/libsrc/pm_v1_0
    ../FM_ZQ_bsp/libsrc/pm_v1_0/: pm_api_sys.c pm_api_sys.h pm_callbacks.c pm_callbacks.h pm_cfg_obj.c pm_cfg_obj.h pm_clock.c pm_clock.h pm_common.h pm_defs.h pm_status.h
  group FM_ZQ_bsp/libsrc/pm_v1_0/apu
    ../FM_ZQ_bsp/libsrc/pm_v1_0/apu/: pm_apu.h pm_client.c pm_client.h
  group FM_ZQ_bsp/libsrc/qspipsu_v1_0
    ../FM_ZQ_bsp/libsrc/qspipsu_v1_0/: fmsh_xspi.c fmsh_xspi.h fmsh_xspi_g.c fmsh_xspi_hw.c fmsh_xspi_hw.h fmsh_xspi_lib.h fmsh_xspi_nor.c fmsh_xspi_nor.h fmsh_xspi_phy.c fmsh_xspi_sinit.c
  group FM_ZQ_bsp/libsrc/rtcps_v1_0
    ../FM_ZQ_bsp/libsrc/rtcps_v1_0/: fmsh_rtc.c fmsh_rtc_common.h fmsh_rtc_g.c fmsh_rtc_lib.h fmsh_rtc_private.h fmsh_rtc_public.h fmsh_rtc_sinit.c
  group FM_ZQ_bsp/libsrc/sdpsu_v1_0
    ../FM_ZQ_bsp/libsrc/sdpsu_v1_0/: fmsh_sdhci.c fmsh_sdhci.h fmsh_sdhci_card.c fmsh_sdhci_card.h fmsh_sdhci_g.c fmsh_sdhci_hw.h fmsh_sdhci_lib.h fmsh_sdhci_phy.c fmsh_sdhci_sinit.c
  group FM_ZQ_bsp/libsrc/spips_v2_0
    ../FM_ZQ_bsp/libsrc/spips_v2_0/: fmsh_spi.c fmsh_spi.h fmsh_spi_eeprom.c fmsh_spi_eeprom.h fmsh_spi_g.c fmsh_spi_hw.c fmsh_spi_hw.h fmsh_spi_lib.h fmsh_spi_sinit.c
  group FM_ZQ_bsp/libsrc/ttcps_v1_1
    ../FM_ZQ_bsp/libsrc/ttcps_v1_1/: fmsh_ttc.c fmsh_ttc_common.h fmsh_ttc_g.c fmsh_ttc_lib.h fmsh_ttc_private.h fmsh_ttc_public.h fmsh_ttc_sinit.c
  group FM_ZQ_bsp/libsrc/uartps_v1_0
    ../FM_ZQ_bsp/libsrc/uartps_v1_0/: fmsh_uart.c fmsh_uart_common.h fmsh_uart_g.c fmsh_uart_lib.h fmsh_uart_private.h fmsh_uart_public.h fmsh_uart_sinit.c
  group FM_ZQ_bsp/libsrc/usbps_v1_0
    ../FM_ZQ_bsp/libsrc/usbps_v1_0/: byteorder.h cdn_assert.h cdn_errno.h cdn_inttypes.h cdn_log.h cdn_stdint.h cdn_stdtypes.h cdn_xhci.c cdn_xhci_if.h cdn_xhci_obj_if.c cdn_xhci_obj_if.h cdn_xhci_priv.h cdn_xhci_sanity.h cdn_xhci_structs_if.h cps.h cps_drv.h cusb_ch9_if.h cusb_ch9_obj_if.h cusb_ch9_sanity.h cusb_ch9_structs_if.h cusbd.c cusbd_if.h cusbd_obj_if.c cusbd_obj_if.h cusbd_sanity.h cusbd_structs_if.h drd.c drd.h drv_testapp_ioctl.h fmsh_usb_data.c fmsh_usb_data.h trb.h usbssp_regs.h usbssp_regs_macros.h xhci_mem_alloc.c
  group FM_ZQ_bsp/libsrc/wdtps_v1_0
    ../FM_ZQ_bsp/libsrc/wdtps_v1_0/: fmsh_wdt.c fmsh_wdt_common.h fmsh_wdt_g.c fmsh_wdt_lib.h fmsh_wdt_private.h fmsh_wdt_public.h fmsh_wdt_sinit.c
  group FM_ZQ_bsp/thirdpartlib/fatfs15
    ../FM_ZQ_bsp/thirdpartlib/Fatfs15/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group FM_ZQ_fsbl
    ../FM_ZQ_fsbl/: boot_main.h boothandoff.c dfu_app.c dfu_app.h dfu_cfg.h fmsh_aes_sm4.c fmsh_aes_sm4.h fmsh_authentication.c fmsh_authentication.h fmsh_board.c fmsh_board.h fmsh_cci_reg.c fmsh_cci_reg.h fmsh_csudma.c fmsh_csudma.h fmsh_dma.c fmsh_dma.h fmsh_efuse.c fmsh_efuse.h fmsh_error.h fmsh_exit.s fmsh_fnand.c fmsh_fnand.h fmsh_gic_selftest.c fmsh_header.c fmsh_header.h fmsh_hw.h fmsh_initialization.c fmsh_partition_load.c fmsh_pmu_interactive.c fmsh_pmu_interactive.h fmsh_qspi.c fmsh_qspi.h fmsh_sac.c fmsh_sac.h fmsh_sd.c fmsh_sd.h fmsh_secure_rsa.c fmsh_secure_rsa.h fmsh_sha.h fmsh_sha256.c fmsh_sha384.c fmsh_uart_logout.c fmsh_uart_logout.h fmsh_watchdog.c fmsh_watchdog.h fsbl_config.h main.c sdmmc_fatfs.c sdmmc_fatfs.h
  group FM_ZQ_hw_platform
    ../FM_ZQ_hw_platform/: ddr_init_data.c gtr_init_data.c psu_init.c psu_init.h
