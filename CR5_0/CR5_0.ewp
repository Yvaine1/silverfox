# IAR project CR5_0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCDefines: CORTEX_R5; SYSTEM_GENERIC; PROCESSOR_ARM; METAL_INTERNAL; SHELL_CFG_USER="shell_cfg_user.h"; FPAR_CPU_ID=0; SHELL_CMD_MASTER=1
  ICCARM.CCIncludePath2: ..\FM_ZQ_hw_platform; ..\FM_ZQ_bsp\include; ..\FM_ZQ_bsp\bootloader; ..\FM_ZQ_bsp\bootloader\cortexr5; ..\FM_ZQ_bsp\libsrc; ..\FM_ZQ_bsp\libsrc\axidmapsu_v1_0; ..\FM_ZQ_bsp\libsrc\bbramps_v1_0; ..\FM_ZQ_bsp\libsrc\canfdps_v1_0; ..\FM_ZQ_bsp\libsrc\ccips_v1_1; ..\FM_ZQ_bsp\libsrc\common_v1_0; ..\FM_ZQ_bsp\libsrc\common_v1_0\cortexr5; ..\FM_ZQ_bsp\libsrc\devcps_v1_0; ..\FM_ZQ_bsp\libsrc\efuseps_v1_0; ..\FM_ZQ_bsp\libsrc\gicps_v1_0; ..\FM_ZQ_bsp\libsrc\gmacpsu_v1_0; ..\FM_ZQ_bsp\libsrc\gmacpsu_v1_0\phy; ..\FM_ZQ_bsp\libsrc\gpiops_v1_1; ..\FM_ZQ_bsp\libsrc\gtc_v1_0; ..\FM_ZQ_bsp\libsrc\gtrpsu_v1_0; ..\FM_ZQ_bsp\libsrc\i2cps_v1_0; ..\FM_ZQ_bsp\libsrc\ipi_v1_1; ..\FM_ZQ_bsp\libsrc\mailbox_v1_1; ..\FM_ZQ_bsp\libsrc\nandpsu_v1_0; ..\FM_ZQ_bsp\libsrc\qspipsu_v1_0; ..\FM_ZQ_bsp\libsrc\rtcps_v1_0; ..\FM_ZQ_bsp\libsrc\sdpsu_v1_0; ..\FM_ZQ_bsp\libsrc\spips_v2_0; ..\FM_ZQ_bsp\libsrc\ttcps_v1_1; ..\FM_ZQ_bsp\libsrc\uartps_v1_0; ..\FM_ZQ_bsp\libsrc\usbps_v1_0; ..\FM_ZQ_bsp\libsrc\wdtps_v1_0; ..\FM_ZQ_bsp\thirdpartlib; ..\FM_ZQ_bsp\thirdpartlib\LetterShell\src; ..\FM_ZQ_bsp\thirdpartlib\LetterShell\portable\freertos; ..\FM_ZQ_bsp\thirdpartlib\FreeRTOSv11\include; ..\FM_ZQ_bsp\thirdpartlib\FreeRTOSv11\portable\IAR\CR5; cr5_0; ..\FM_ZQ_bsp\thirdpartlib\Ushell_r51\include\ushell; ..\FM_ZQ_bsp\thirdpartlib\RingBuffer; ..\FM_ZQ_bsp\r5app\common\inc; ..\FM_ZQ_bsp\r5app\example; ..\FM_ZQ_bsp\r5app\rfdc\header; ..\FM_ZQ_bsp\r5app\shell; ..\FM_ZQ_bsp\r5app\spi_cx4e04\header; ..\FM_ZQ_bsp\r5app\rfdc\app; ..\FM_ZQ_bsp\r5app\common\src; ..\FM_ZQ_bsp\r5app\spi_cx4e04\app; ..\FM_ZQ_bsp\thirdpartlib\rfdc_v11_1\src; ..\FM_ZQ_bsp\r5app\i2c_dac80501\header; ..\FM_ZQ_bsp\r5app\i2c_dac80501\src; ..\FM_ZQ_bsp\r5app\i2c_lm75\header; ..\Examples; ..\FM_ZQ_bsp\thirdpartlib\Libmetal_v1_5\include; ..\FM_ZQ_bsp\thirdpartlib\Libmetal_v1_5\include\metal\system\generic; ..\FM_ZQ_bsp\thirdpartlib\nr_shm; ..\FM_ZQ_bsp\pl\libsrc\iic_v3_9\src; ..\FM_ZQ_bsp\pl\include; ..\FM_ZQ_bsp\r5app\eeprom\src; ..\FM_ZQ_bsp\r5app\i2c_dac4651\src; ..\FM_ZQ_bsp\r5app\eeprom\header; ..\FM_ZQ_bsp\r5app\i2c_dac4651\inc; ..\FM_ZQ_bsp\r5app\freq_offset_calibration; ..\FM_ZQ_bsp\r5app\i2c_nst175\inc; ..\FM_ZQ_bsp\r5app\i2c_nst175\src; ..\FM_ZQ_bsp\r5app\gpio\inc; ..\FM_ZQ_bsp\r5app\tod_utc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\FM_ZQ_hw_platform; ..\FM_ZQ_bsp\include; ..\FM_ZQ_bsp\bootloader; ..\FM_ZQ_bsp\bootloader\cortexr5; ..\FM_ZQ_bsp\libsrc; ..\FM_ZQ_bsp\libsrc\common_v1_0; ..\FM_ZQ_bsp\libsrc\gicps_v1_0; ..\FM_ZQ_bsp\libsrc\gtc_v1_0; ..\FM_ZQ_bsp\libsrc\nandpsu_v1_0; ..\FM_ZQ_bsp\libsrc\qspipsu_v1_0; ..\FM_ZQ_bsp\libsrc\sdpsu_v1_0; ..\FM_ZQ_bsp\libsrc\spips_v2_0; ..\FM_ZQ_bsp\libsrc\ttcps_v1_0; ..\FM_ZQ_bsp\libsrc\uartps_v1_0; ..\FM_ZQ_bsp\thirdpartlib\FreeRTOSv11\portable\IAR\CR5; FreeRTOS
  OBJCOPY.OOCOutputFile: CR5_0.bin
  ILINK.IlinkOutputFile: CR5_0.out
  ILINK.IlinkIcfFile: cr5_0_ddr.icf
  ILINK.IlinkProgramEntryLabel: Vectors
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CR5_0
    cr5_0/: backtrace.c backtrace.h fmsh_ipi_init.c fmsh_ipi_init.h fmsh_print.c fmsh_print.h FreeRTOSConfig.h l1c_r50.h main.c mem_common.h platform.c platform.h set_trx_gain.c set_trx_gain.h shell_cfg_user.h shell_cmd_l1c.c shell_cmd_l1c.h symbol_table.h symbol_table_stub.c
    ../FM_ZQ_bsp/thirdpartlib/LetterShell/src/: shell_export_cmd_r50.c
    generated/: symbol_table.c
  group FM_ZQ_bsp/bootloader/cortexr5
    ../FM_ZQ_bsp/bootloader/cortexr5/: bspconfig.h exception_handler.c exception_handler.h startup.S vectors.S
  group FM_ZQ_bsp/include
    ../FM_ZQ_bsp/include/: fmsh_parameters.h fmsh_psu_parameters.h
  group FM_ZQ_bsp/lib
    ../FM_ZQ_bsp/lib/: libnr_shm.a libphy_r50.a
  group FM_ZQ_bsp/libsrc/axidmapsu_v1_0
    ../FM_ZQ_bsp/libsrc/axidmapsu_v1_0/: fmsh_axidmapsu.c fmsh_axidmapsu.h fmsh_axidmapsu_g.c fmsh_axidmapsu_hw.h fmsh_axidmapsu_lib.h
  group FM_ZQ_bsp/libsrc/bbramps_v1_0
    ../FM_ZQ_bsp/libsrc/bbramps_v1_0/: fmsh_bbram.c fmsh_bbram_common.h fmsh_bbram_g.c fmsh_bbram_lib.h fmsh_bbram_private.h fmsh_bbram_public.h fmsh_bbram_sinit.c
  group FM_ZQ_bsp/libsrc/canfd_v1_0
    ../FM_ZQ_bsp/libsrc/canfdps_v1_0/: fmsh_can.c fmsh_can_common.h fmsh_can_g.c fmsh_can_lib.h fmsh_can_private.h fmsh_can_public.h fmsh_can_sinit.c
  group FM_ZQ_bsp/libsrc/cci_v1_0
    ../FM_ZQ_bsp/libsrc/ccips_v1_1/: fmsh_cci.c fmsh_cci.h fmsh_cci_hw.h
  group FM_ZQ_bsp/libsrc/common_v1_0
    ../FM_ZQ_bsp/libsrc/common_v1_0/: fmsh_common.c fmsh_common.h fmsh_common_bitops.h fmsh_common_dbc.h fmsh_common_delay.h fmsh_common_dev.h fmsh_common_io.h fmsh_common_list.h fmsh_common_status.h fmsh_common_types.h fmsh_pseudo_asm.h
  group FM_ZQ_bsp/libsrc/common_v1_0/cortexr5
    ../FM_ZQ_bsp/libsrc/common_v1_0/cortexr5/: cortexr5.h fmsh_cache.c fmsh_cache.h fmsh_delay.c fmsh_mpu.c fmsh_mpu.h fmsh_pmu.c fmsh_pmu.h
  group FM_ZQ_bsp/libsrc/devcps_v1_0
    ../FM_ZQ_bsp/libsrc/devcps_v1_0/: fmsh_devc.c fmsh_devc_common.h fmsh_devc_g.c fmsh_devc_lib.h fmsh_devc_private.h fmsh_devc_public.h fmsh_devc_sinit.c
  group FM_ZQ_bsp/libsrc/efuseps_v1_0
    ../FM_ZQ_bsp/libsrc/efuseps_v1_0/: fmsh_efuse.c fmsh_efuse.h
  group FM_ZQ_bsp/libsrc/gicps_v1_0
    ../FM_ZQ_bsp/libsrc/gicps_v1_0/: fmsh_gic.c fmsh_gic.h fmsh_gic_hw.h fmsh_gic_intr.c fmsh_gic_sinit.c
  group FM_ZQ_bsp/libsrc/gmacpsu_v1_0
    ../FM_ZQ_bsp/libsrc/gmacpsu_v1_0/: fmsh_gmac.c fmsh_gmac.h fmsh_gmac_assert.c fmsh_gmac_assert.h fmsh_gmac_bd.c fmsh_gmac_bd.h fmsh_gmac_g.c fmsh_gmac_hw.c fmsh_gmac_hw.h fmsh_gmac_sinit.c fmsh_gmac_status.h
  group FM_ZQ_bsp/libsrc/gmacpsu_v1_0/phy
    ../FM_ZQ_bsp/libsrc/gmacpsu_v1_0/phy/: fmsh_gmac_mdio.c fmsh_gmac_mdio.h marvell_88e1512.c marvell_88e1512.h microchip_ksz9031RNX.c microchip_ksz9031RNX.h motorcomm_yt8521.c motorcomm_yt8521.h
  group FM_ZQ_bsp/libsrc/gpiops_v1_1
    ../FM_ZQ_bsp/libsrc/gpiops_v1_1/: fmsh_gpio.c fmsh_gpio_common.h fmsh_gpio_g.c fmsh_gpio_lib.h fmsh_gpio_private.h fmsh_gpio_public.h fmsh_gpio_sinit.c
  group FM_ZQ_bsp/libsrc/gtcps_v1_0
    ../FM_ZQ_bsp/libsrc/gtc_v1_0/: fmsh_gtc.c fmsh_gtc_common.h fmsh_gtc_g.c fmsh_gtc_lib.h fmsh_gtc_private.h fmsh_gtc_public.h fmsh_gtc_sinit.c
  group FM_ZQ_bsp/libsrc/gtrpsu_v1_0
    ../FM_ZQ_bsp/libsrc/gtrpsu_v1_0/: fmsh_gtr.c fmsh_gtr.h
  group FM_ZQ_bsp/libsrc/i2cps_1_0
    ../FM_ZQ_bsp/libsrc/i2cps_v1_0/: fmsh_i2c.c fmsh_i2c_common.h fmsh_i2c_g.c fmsh_i2c_lib.h fmsh_i2c_private.h fmsh_i2c_public.h fmsh_i2c_sinit.c
  group FM_ZQ_bsp/libsrc/ipi_v1_1
    ../FM_ZQ_bsp/libsrc/ipi_v1_1/: fmsh_ipi.c fmsh_ipi.h fmsh_ipi_buf.c fmsh_ipi_buf.h fmsh_ipi_g.c fmsh_ipi_hw.h fmsh_ipi_sinit.c
  group FM_ZQ_bsp/libsrc/mailbox_v1_1
    ../FM_ZQ_bsp/libsrc/mailbox_v1_1/: fmsh_mailbox.c fmsh_mailbox.h fmsh_mailbox_ipips.c fmsh_mailbox_ipips.h
  group FM_ZQ_bsp/libsrc/nandpsu_v1_0
    ../FM_ZQ_bsp/libsrc/nandpsu_v1_0/: fmsh_hpnfc.c fmsh_hpnfc.h fmsh_hpnfc_bbm.c fmsh_hpnfc_bbm.h fmsh_hpnfc_flash.c fmsh_hpnfc_flash.h fmsh_hpnfc_g.c fmsh_hpnfc_hw.c fmsh_hpnfc_hw.h fmsh_hpnfc_sinit.c fmsh_hpnfc_skip.c fmsh_hpnfc_skip.h
  group FM_ZQ_bsp/libsrc/qspipsu_v1_0
    ../FM_ZQ_bsp/libsrc/qspipsu_v1_0/: fmsh_xspi.c fmsh_xspi.h fmsh_xspi_g.c fmsh_xspi_hw.c fmsh_xspi_hw.h fmsh_xspi_lib.h fmsh_xspi_nor.c fmsh_xspi_nor.h fmsh_xspi_phy.c fmsh_xspi_sinit.c
  group FM_ZQ_bsp/libsrc/rtcps_v1_0
    ../FM_ZQ_bsp/libsrc/rtcps_v1_0/: fmsh_rtc.c fmsh_rtc_common.h fmsh_rtc_g.c fmsh_rtc_lib.h fmsh_rtc_private.h fmsh_rtc_public.h fmsh_rtc_sinit.c
  group FM_ZQ_bsp/libsrc/sdpsu_v1_0
    ../FM_ZQ_bsp/libsrc/sdpsu_v1_0/: fmsh_sdhci.c fmsh_sdhci.h fmsh_sdhci_card.c fmsh_sdhci_card.h fmsh_sdhci_g.c fmsh_sdhci_hw.h fmsh_sdhci_lib.h fmsh_sdhci_phy.c fmsh_sdhci_sinit.c
  group FM_ZQ_bsp/libsrc/spips_v2_0
    ../FM_ZQ_bsp/libsrc/spips_v2_0/: fmsh_spi.c fmsh_spi.h fmsh_spi_eeprom.c fmsh_spi_eeprom.h fmsh_spi_g.c fmsh_spi_hw.c fmsh_spi_hw.h fmsh_spi_lib.h fmsh_spi_sinit.c
  group FM_ZQ_bsp/libsrc/ttcps_v1_1
    ../FM_ZQ_bsp/libsrc/ttcps_v1_1/: fmsh_ttc.c fmsh_ttc_common.h fmsh_ttc_g.c fmsh_ttc_lib.h fmsh_ttc_private.h fmsh_ttc_public.h fmsh_ttc_sinit.c
  group FM_ZQ_bsp/libsrc/uartps_v1_0
    ../FM_ZQ_bsp/libsrc/uartps_v1_0/: fmsh_uart.c fmsh_uart_common.h fmsh_uart_g.c fmsh_uart_lib.h fmsh_uart_private.h fmsh_uart_public.h fmsh_uart_sinit.c
  group FM_ZQ_bsp/libsrc/usbps_v1_0
    ../FM_ZQ_bsp/libsrc/usbps_v1_0/: byteorder.h cdn_assert.h cdn_errno.h cdn_inttypes.h cdn_log.h cdn_stdint.h cdn_stdtypes.h cdn_xhci.c cdn_xhci_if.h cdn_xhci_obj_if.c cdn_xhci_obj_if.h cdn_xhci_priv.h cdn_xhci_sanity.h cdn_xhci_structs_if.h cps.h cps_drv.h cusb_ch9_if.h cusb_ch9_obj_if.h cusb_ch9_sanity.h cusb_ch9_structs_if.h cusbd.c cusbd_if.h cusbd_obj_if.c cusbd_obj_if.h cusbd_sanity.h cusbd_structs_if.h drd.c drd.h drv_testapp_ioctl.h fmsh_usb_data.c fmsh_usb_data.h trb.h usbssp_regs.h usbssp_regs_macros.h xhci_mem_alloc.c
  group FM_ZQ_bsp/libsrc/wdtps_v1_0
    ../FM_ZQ_bsp/libsrc/wdtps_v1_0/: fmsh_wdt.c fmsh_wdt_common.h fmsh_wdt_g.c fmsh_wdt_lib.h fmsh_wdt_private.h fmsh_wdt_public.h fmsh_wdt_sinit.c
  group FM_ZQ_bsp/pl/axii2c
    ../FM_ZQ_bsp/pl/libsrc/iic_v3_9/src/: xiic.c xiic.h xiic_dyn_master.c xiic_g.c xiic_i.h xiic_intr.c xiic_l.c xiic_l.h xiic_master.c xiic_multi_master.c xiic_options.c xiic_selftest.c xiic_sinit.c xiic_slave.c xiic_stats.c
  group FM_ZQ_bsp/pl/inc
    ../FM_ZQ_bsp/pl/include/: xparameters.h xparameters01.h xparameters_ps.h
  group FM_ZQ_bsp/r5app/dac4651/inc
    ../FM_ZQ_bsp/r5app/i2c_dac4651/inc/: dac4651_api.h dac4651_main.h
  group FM_ZQ_bsp/r5app/dac4651/src
    ../FM_ZQ_bsp/r5app/i2c_dac4651/src/: dac4651_api.c dac4651_main.c
  group FM_ZQ_bsp/r5app/eeprom/inc
    ../FM_ZQ_bsp/r5app/eeprom/header/: crc32.h eeprom_api.h eeprom_main.h
  group FM_ZQ_bsp/r5app/eeprom/src
    ../FM_ZQ_bsp/r5app/eeprom/src/: crc32.c eeprom_api.c eeprom_main.c
  group FM_ZQ_bsp/r5app/example
    ../FM_ZQ_bsp/r5app/example/: common.h FreeRTOSConfig.h libmetal_amp_demod.c platform_config.h sys_init.c sys_init.h
  group FM_ZQ_bsp/r5app/freq_offset_calibration
    ../FM_ZQ_bsp/r5app/freq_offset_calibration/: freq_offset_calibration.c freq_offset_calibration.h
  group FM_ZQ_bsp/r5app/gpio/inc
    ../FM_ZQ_bsp/r5app/gpio/inc/: gpio_api.h gpio_main.h
  group FM_ZQ_bsp/r5app/gpio/src
    ../FM_ZQ_bsp/r5app/gpio/src/: gpio_api.c gpio_main.c
  group FM_ZQ_bsp/r5app/nst175/inc
    ../FM_ZQ_bsp/r5app/i2c_nst175/inc/: nst175_api.h nst175_main.h
  group FM_ZQ_bsp/r5app/nst175/src
    ../FM_ZQ_bsp/r5app/i2c_nst175/src/: nst175_api.c nst175_main.c
  group FM_ZQ_bsp/r5app/rfdc
    ../FM_ZQ_bsp/r5app/rfdc/header/: xrfdc_api.h xrfdc_main.h
    ../FM_ZQ_bsp/r5app/rfdc/app/: xrfdc_main.c xrfdx_api.c
  group FM_ZQ_bsp/r5app/shell
    ../FM_ZQ_bsp/r5app/shell/: portable.h shell.c shell.h shell_cfg.h shell_cmd.c shell_cmd_list.c shell_companion.c shell_ext.c shell_ext.h shell_port.c shell_port.h
  group FM_ZQ_bsp/r5app/spi_cx4e04
    ../FM_ZQ_bsp/r5app/spi_cx4e04/app/: cx4e04_config.c
    ../FM_ZQ_bsp/r5app/spi_cx4e04/header/: cx4e04_config.h
  group FM_ZQ_bsp/r5app/tod_utc
    ../FM_ZQ_bsp/r5app/tod_utc/: dg_tod_utc.c dg_tod_utc.h
  group FM_ZQ_bsp/thirdpartlib/fatfs15
    ../FM_ZQ_bsp/thirdpartlib/Fatfs15/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group FM_ZQ_bsp/thirdpartlib/freertosv11
    ../FM_ZQ_bsp/thirdpartlib/FreeRTOSv11/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FM_ZQ_bsp/thirdpartlib/freertosv11/portable
    ../FM_ZQ_bsp/thirdpartlib/FreeRTOSv11/portable/MemMang/: heap_4.c
    ../FM_ZQ_bsp/thirdpartlib/FreeRTOSv11/portable/Common/: mpu_wrappers.c
    ../FM_ZQ_bsp/thirdpartlib/FreeRTOSv11/portable/IAR/CR5/: port.c port_asm_vectors.S portASM.h portASM.s portmacro.h
  group FM_ZQ_bsp/thirdpartlib/lettershell/portable
    ../FM_ZQ_bsp/thirdpartlib/LetterShell/portable/freertos/: shell_port.c shell_port.h
  group FM_ZQ_bsp/thirdpartlib/lettershell/src
    ../FM_ZQ_bsp/thirdpartlib/LetterShell/src/: shell.c shell.h shell_cfg.h shell_cmd_list.c shell_companion.c shell_ext.c shell_ext.h
  group FM_ZQ_bsp/thirdpartlib/libmetal
    ../FM_ZQ_bsp/thirdpartlib/Libmetal_v1_5/src/: device.c dma.c init.c io.c irq.c log.c shmem.c softirq.c version.c
    ../FM_ZQ_bsp/thirdpartlib/Libmetal_v1_5/include/: metal_config.h
  group FM_ZQ_bsp/thirdpartlib/libmetal/system/generic
    ../FM_ZQ_bsp/thirdpartlib/Libmetal_v1_5/src/system/generic/: condition.c device.c init.c io.c irq.c shmem.c time.c
  group FM_ZQ_bsp/thirdpartlib/libmetal/system/generic/fmsh
    ../FM_ZQ_bsp/thirdpartlib/Libmetal_v1_5/src/system/generic/fmsh/: irq.c sys.c
  group FM_ZQ_bsp/thirdpartlib/rfdc_v11_1
    ../FM_ZQ_bsp/thirdpartlib/rfdc_v11_1/src/: xil_io.h xrfdc.c xrfdc.h xrfdc_ap.c xrfdc_clock.c xrfdc_dp.c xrfdc_g.c xrfdc_hw.h xrfdc_intr.c xrfdc_mb.c xrfdc_mixer.c xrfdc_mts.c xrfdc_sinit.c xstatus.h
  group FM_ZQ_bsp/thirdpartlib/RingBuffer
    ../FM_ZQ_bsp/thirdpartlib/RingBuffer/: ring_buffer.c ring_buffer.h
  group FM_ZQ_hw_platform
    ../FM_ZQ_hw_platform/: ddr_init_data.c gtr_init_data.c psu_init.c psu_init.h
