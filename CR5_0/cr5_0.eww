<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\CA53\CA53.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\CR5_0.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\CR5_1\CR5_1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\FSBL\FSBL.ewp</path>
    </project>
    <batchBuild />
</workspace>
