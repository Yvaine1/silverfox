# IAR project CA53_BOOT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 68
  General.FPU2: 0
  ICCARM.CCDefines: NO_OS=1
  ICCARM.CCIncludePath2: ..\FM_ZQ_hw_platform; ..\FM_ZQ_bsp\include; ..\FM_ZQ_bsp\bootloader; ..\FM_ZQ_bsp\bootloader\armv8; ..\FM_ZQ_bsp\libsrc; ..\FM_ZQ_bsp\libsrc\axidmapsu_v1_0; ..\FM_ZQ_bsp\libsrc\bbramps_v1_0; ..\FM_ZQ_bsp\libsrc\canfdps_v1_0; ..\FM_ZQ_bsp\libsrc\ccips_v1_1; ..\FM_ZQ_bsp\libsrc\common_v1_0; ..\FM_ZQ_bsp\libsrc\common_v1_0\armv8; ..\FM_ZQ_bsp\libsrc\devcps_v1_0; ..\FM_ZQ_bsp\libsrc\efuseps_v1_0; ..\FM_ZQ_bsp\libsrc\gicps_v1_0; ..\FM_ZQ_bsp\libsrc\gmacpsu_v1_0; ..\FM_ZQ_bsp\libsrc\gmacpsu_v1_0\phy; ..\FM_ZQ_bsp\libsrc\gpiops_v1_1; ..\FM_ZQ_bsp\libsrc\gtc_v1_0; ..\FM_ZQ_bsp\libsrc\gtrpsu_v1_0; ..\FM_ZQ_bsp\libsrc\i2cps_v1_0; ..\FM_ZQ_bsp\libsrc\ipi_v1_1; ..\FM_ZQ_bsp\libsrc\mailbox_v1_1; ..\FM_ZQ_bsp\libsrc\nandpsu_v1_0; ..\FM_ZQ_bsp\libsrc\qspipsu_v1_0; ..\FM_ZQ_bsp\libsrc\rtcps_v1_0; ..\FM_ZQ_bsp\libsrc\sdpsu_v1_0; ..\FM_ZQ_bsp\libsrc\spips_v2_0; ..\FM_ZQ_bsp\libsrc\ttcps_v1_1; ..\FM_ZQ_bsp\libsrc\uartps_v1_0; ..\FM_ZQ_bsp\libsrc\usbps_v1_0; ..\FM_ZQ_bsp\libsrc\wdtps_v1_0; ..\FM_ZQ_bsp\thirdpartlib; ..\FM_ZQ_bsp\thirdpartlib\FTP; ..\FM_ZQ_bsp\thirdpartlib\Fatfs15; ca53_boot; boot_shell; boot_load; ..\Examples; ..\FM_ZQ_bsp\libsrc\pm_v1_0; ..\FM_ZQ_fsbl; boot_lwip212; boot_lwip212\arch; boot_lwip212\include; boot_lwip212\include\lwip; boot_lwip212\include\netif; boot_lwip212\include\lwip\apps; boot_lwip212\include\lwip\priv; boot_lwip212\include\lwip\prot; boot_rtc; ..\FM_ZQ_bsp\r5app\eeprom\header; ..\FM_ZQ_bsp\r5app\common\inc; boot_eeprom
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\FM_ZQ_hw_platform; ..\FM_ZQ_bsp\include; ..\FM_ZQ_bsp\bootloader; ..\FM_ZQ_bsp\bootloader\armv8; ..\FM_ZQ_bsp\libsrc; ..\FM_ZQ_bsp\libsrc\common_v1_0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ca53_boot_ddr.icf
  ILINK.IlinkProgramEntryLabel: Start64
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CA53_BOOT
    ../FM_ZQ_bsp/r5app/eeprom/src/: eeprom_api.c
    ca53_boot/: fadapter.c fadapter.h fmsh_gmacpsif.c fmsh_gmacpsif.h fmsh_gmacpsif_dma.c fmsh_lwipconfig.h fmsh_pqueue.c fmsh_pqueue.h fmsh_print.c fmsh_print.h ftopology.h main.c platform.c platform.h
    ../Examples/: fmsh_gic_selftest.c fmsh_qspi_example.c fmsh_qspi_example.h fmsh_sdmmc_example.c fmsh_sdmmc_example.h
  group CA53_BOOT/app
    ca53_boot/: echo.c tcp_perf_client.c tcp_perf_client.h udp_perf_client.c udp_perf_client.h
  group CA53_BOOT/boot_eeprom
    boot_eeprom/: boot_eeprom_api.c boot_eeprom_api.h
  group CA53_BOOT/boot_load
    ../FM_ZQ_fsbl/: boothandoff.c fmsh_exit.s fmsh_qspi.c fmsh_sac.c
    boot_load/: crc32.c crc32.h fpga.c fpga.h load_img.c load_img.h release_rpu.c release_rpu.h version_info.h
  group CA53_BOOT/BOOT_LWIP212/api
    boot_lwip212/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group CA53_BOOT/BOOT_LWIP212/arch
    boot_lwip212/arch/: bpstruct.h cc.h epstruct.h ethernetif.h lwipopts.h perf.h sys_arch.c sys_arch.h
  group CA53_BOOT/BOOT_LWIP212/core
    boot_lwip212/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group CA53_BOOT/BOOT_LWIP212/core/ipv4
    boot_lwip212/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group CA53_BOOT/BOOT_LWIP212/core/ipv6
    boot_lwip212/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group CA53_BOOT/BOOT_LWIP212/include/lwip
    boot_lwip212/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group CA53_BOOT/BOOT_LWIP212/include/lwip/apps
    boot_lwip212/include/lwip/apps/: altcp_proxyconnect.h altcp_tls_mbedtls_opts.h fs.h http_client.h httpd.h httpd_opts.h lwiperf.h mdns.h mdns_opts.h mdns_priv.h mqtt.h mqtt_opts.h mqtt_priv.h netbiosns.h netbiosns_opts.h smtp.h smtp_opts.h snmp.h snmp_core.h snmp_mib2.h snmp_opts.h snmp_scalar.h snmp_snmpv2_framework.h snmp_snmpv2_usm.h snmp_table.h snmp_threadsync.h snmpv3.h sntp.h sntp_opts.h tftp_opts.h tftp_server.h
  group CA53_BOOT/BOOT_LWIP212/include/lwip/priv
    boot_lwip212/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group CA53_BOOT/BOOT_LWIP212/include/lwip/prot
    boot_lwip212/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group CA53_BOOT/BOOT_LWIP212/include/netif
    boot_lwip212/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group CA53_BOOT/BOOT_LWIP212/netif
    boot_lwip212/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group CA53_BOOT/boot_rtc
    boot_rtc/: fmsh_rtc_mix.c fmsh_rtc_mix.h
  group CA53_BOOT/boot_shell
    boot_shell/: portable.h shell.c shell.h shell_cfg.h shell_cmd.c shell_cmd_list.c shell_companion.c shell_ext.c shell_ext.h shell_port.c shell_port.h
  group FM_ZQ_bsp/bootloader/armv8
    ../FM_ZQ_bsp/bootloader/armv8/: bspconfig.h exception_handler.c exception_handler.h startup.S translation_table_ca53boot.S translation_table_el1_ca53boot.S vectors.S
  group FM_ZQ_bsp/include
    ../FM_ZQ_bsp/include/: fmsh_parameters.h fmsh_psu_parameters.h
  group FM_ZQ_bsp/libsrc/axidmapsu_v1_0
    ../FM_ZQ_bsp/libsrc/axidmapsu_v1_0/: fmsh_axidmapsu.c fmsh_axidmapsu.h fmsh_axidmapsu_g.c fmsh_axidmapsu_hw.h fmsh_axidmapsu_lib.h
  group FM_ZQ_bsp/libsrc/bbramps_v1_0
    ../FM_ZQ_bsp/libsrc/bbramps_v1_0/: fmsh_bbram.c fmsh_bbram_common.h fmsh_bbram_g.c fmsh_bbram_lib.h fmsh_bbram_private.h fmsh_bbram_public.h fmsh_bbram_sinit.c
  group FM_ZQ_bsp/libsrc/canfdps_v1_0
    ../FM_ZQ_bsp/libsrc/canfdps_v1_0/: fmsh_can.c fmsh_can_common.h fmsh_can_g.c fmsh_can_lib.h fmsh_can_private.h fmsh_can_public.h fmsh_can_sinit.c
  group FM_ZQ_bsp/libsrc/ccips_v1_1
    ../FM_ZQ_bsp/libsrc/ccips_v1_1/: fmsh_cci.c fmsh_cci.h fmsh_cci_hw.h
  group FM_ZQ_bsp/libsrc/common_v1_0
    ../FM_ZQ_bsp/libsrc/common_v1_0/: fmsh_common.c fmsh_common.h fmsh_common_bitops.h fmsh_common_dbc.h fmsh_common_delay.h fmsh_common_dev.h fmsh_common_io.h fmsh_common_list.h fmsh_common_status.h fmsh_common_types.h fmsh_gtc_delay.c iar_retarget.c
  group FM_ZQ_bsp/libsrc/common_v1_0/armv8
    ../FM_ZQ_bsp/libsrc/common_v1_0/armv8/: cortexa53.h fmsh_cache.c fmsh_cache.h fmsh_mmu.c fmsh_mmu.h PPM_AEM.h v8_aarch64.S v8_mmu.h v8_system.h v8_utils.S
    ../FM_ZQ_bsp/libsrc/common_v1_0/: fmsh_pseudo_asm.h
  group FM_ZQ_bsp/libsrc/devcps_v1_0
    ../FM_ZQ_bsp/libsrc/devcps_v1_0/: fmsh_devc.c fmsh_devc_common.h fmsh_devc_g.c fmsh_devc_lib.h fmsh_devc_private.h fmsh_devc_public.h fmsh_devc_sinit.c
  group FM_ZQ_bsp/libsrc/efuseps_v1_0
    ../FM_ZQ_bsp/libsrc/efuseps_v1_0/: fmsh_efuse.c fmsh_efuse.h
  group FM_ZQ_bsp/libsrc/gicps_v1_0
    ../FM_ZQ_bsp/libsrc/gicps_v1_0/: fmsh_gic.c fmsh_gic.h fmsh_gic_hw.h fmsh_gic_intr.c fmsh_gic_sinit.c
  group FM_ZQ_bsp/libsrc/gmacpsu_v1_0
    ../FM_ZQ_bsp/libsrc/gmacpsu_v1_0/: fmsh_gmac.c fmsh_gmac.h fmsh_gmac_assert.c fmsh_gmac_assert.h fmsh_gmac_bd.c fmsh_gmac_bd.h fmsh_gmac_g.c fmsh_gmac_hw.c fmsh_gmac_hw.h fmsh_gmac_sinit.c fmsh_gmac_status.h
  group FM_ZQ_bsp/libsrc/gmacpsu_v1_0/phy
    ../FM_ZQ_bsp/libsrc/gmacpsu_v1_0/phy/: fmsh_gmac_mdio.c fmsh_gmac_mdio.h jl2xx1.c jl2xx1.h marvell_88e1512.c marvell_88e1512.h microchip_ksz9031RNX.c microchip_ksz9031RNX.h motorcomm_yt8521.c motorcomm_yt8521.h
  group FM_ZQ_bsp/libsrc/gpiops_v1_1
    ../FM_ZQ_bsp/libsrc/gpiops_v1_1/: fmsh_gpio.c fmsh_gpio_common.h fmsh_gpio_g.c fmsh_gpio_lib.h fmsh_gpio_private.h fmsh_gpio_public.h fmsh_gpio_sinit.c
  group FM_ZQ_bsp/libsrc/gtcps_v1_0
    ../FM_ZQ_bsp/libsrc/gtc_v1_0/: fmsh_gtc.c fmsh_gtc_common.h fmsh_gtc_g.c fmsh_gtc_lib.h fmsh_gtc_private.h fmsh_gtc_public.h fmsh_gtc_sinit.c
  group FM_ZQ_bsp/libsrc/gtrpsu_v1_0
    ../FM_ZQ_bsp/libsrc/gtrpsu_v1_0/: fmsh_gtr.c fmsh_gtr.h
  group FM_ZQ_bsp/libsrc/i2cps_v1_0
    ../FM_ZQ_bsp/libsrc/i2cps_v1_0/: fmsh_i2c.c fmsh_i2c_common.h fmsh_i2c_g.c fmsh_i2c_lib.h fmsh_i2c_private.h fmsh_i2c_public.h fmsh_i2c_sinit.c
  group FM_ZQ_bsp/libsrc/ipi_v1_1
    ../FM_ZQ_bsp/libsrc/ipi_v1_1/: fmsh_ipi.c fmsh_ipi.h fmsh_ipi_buf.c fmsh_ipi_buf.h fmsh_ipi_g.c fmsh_ipi_hw.h fmsh_ipi_sinit.c
  group FM_ZQ_bsp/libsrc/mailbox_v1_1
    ../FM_ZQ_bsp/libsrc/mailbox_v1_1/: fmsh_mailbox.c fmsh_mailbox.h fmsh_mailbox_ipips.c fmsh_mailbox_ipips.h
  group FM_ZQ_bsp/libsrc/nandpsu_v1_0
    ../FM_ZQ_bsp/libsrc/nandpsu_v1_0/: fmsh_hpnfc.c fmsh_hpnfc.h fmsh_hpnfc_bbm.c fmsh_hpnfc_bbm.h fmsh_hpnfc_flash.c fmsh_hpnfc_flash.h fmsh_hpnfc_g.c fmsh_hpnfc_hw.c fmsh_hpnfc_hw.h fmsh_hpnfc_sinit.c fmsh_hpnfc_skip.c fmsh_hpnfc_skip.h
  group FM_ZQ_bsp/libsrc/qspipsu_v1_0
    ../FM_ZQ_bsp/libsrc/qspipsu_v1_0/: fmsh_xspi.c fmsh_xspi.h fmsh_xspi_g.c fmsh_xspi_hw.c fmsh_xspi_hw.h fmsh_xspi_lib.h fmsh_xspi_nor.c fmsh_xspi_nor.h fmsh_xspi_phy.c fmsh_xspi_sinit.c
  group FM_ZQ_bsp/libsrc/rtcps_v1_0
    ../FM_ZQ_bsp/libsrc/rtcps_v1_0/: fmsh_rtc.c fmsh_rtc_common.h fmsh_rtc_g.c fmsh_rtc_lib.h fmsh_rtc_private.h fmsh_rtc_public.h fmsh_rtc_sinit.c
  group FM_ZQ_bsp/libsrc/sdpsu_v1_0
    ../FM_ZQ_bsp/libsrc/sdpsu_v1_0/: fmsh_sdhci.c fmsh_sdhci.h fmsh_sdhci_card.c fmsh_sdhci_card.h fmsh_sdhci_g.c fmsh_sdhci_hw.h fmsh_sdhci_lib.h fmsh_sdhci_phy.c fmsh_sdhci_pro.c fmsh_sdhci_pro.h fmsh_sdhci_sinit.c
  group FM_ZQ_bsp/libsrc/spips_v2_0
    ../FM_ZQ_bsp/libsrc/spips_v2_0/: fmsh_spi.c fmsh_spi.h fmsh_spi_eeprom.c fmsh_spi_eeprom.h fmsh_spi_g.c fmsh_spi_hw.c fmsh_spi_hw.h fmsh_spi_lib.h fmsh_spi_sinit.c
  group FM_ZQ_bsp/libsrc/ttcps_v1_1
    ../FM_ZQ_bsp/libsrc/ttcps_v1_1/: fmsh_ttc.c fmsh_ttc_common.h fmsh_ttc_g.c fmsh_ttc_lib.h fmsh_ttc_private.h fmsh_ttc_public.h fmsh_ttc_sinit.c
  group FM_ZQ_bsp/libsrc/uartps_v1_0
    ../FM_ZQ_bsp/libsrc/uartps_v1_0/: fmsh_uart.c fmsh_uart_common.h fmsh_uart_g.c fmsh_uart_lib.h fmsh_uart_private.h fmsh_uart_public.h fmsh_uart_sinit.c
  group FM_ZQ_bsp/libsrc/usbps_v1_0
    ../FM_ZQ_bsp/libsrc/usbps_v1_0/: byteorder.h cdn_assert.h cdn_errno.h cdn_inttypes.h cdn_log.h cdn_stdint.h cdn_stdtypes.h cdn_xhci.c cdn_xhci_if.h cdn_xhci_obj_if.c cdn_xhci_obj_if.h cdn_xhci_priv.h cdn_xhci_sanity.h cdn_xhci_structs_if.h cps.h cps_drv.h cusb_ch9_if.h cusb_ch9_obj_if.h cusb_ch9_sanity.h cusb_ch9_structs_if.h cusbd.c cusbd_if.h cusbd_obj_if.c cusbd_obj_if.h cusbd_sanity.h cusbd_structs_if.h drd.c drd.h drv_testapp_ioctl.h trb.h usbssp_regs.h usbssp_regs_macros.h xhci_mem_alloc.c
  group FM_ZQ_bsp/libsrc/wdtps_v1_0
    ../FM_ZQ_bsp/libsrc/wdtps_v1_0/: fmsh_wdt.c fmsh_wdt_common.h fmsh_wdt_g.c fmsh_wdt_lib.h fmsh_wdt_private.h fmsh_wdt_public.h fmsh_wdt_sinit.c
  group FM_ZQ_bsp/thirdpartlib/fatfs15
    ../FM_ZQ_bsp/thirdpartlib/Fatfs15/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group FM_ZQ_bsp/thirdpartlib/FTP
    ../FM_ZQ_bsp/thirdpartlib/ftp/: ftpd.c ftpd.h
  group FM_ZQ_hw_platform
    ../FM_ZQ_hw_platform/: ddr_init_data.c gtr_init_data.c psu_init.c psu_init.h
